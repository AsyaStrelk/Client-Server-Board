# IAR project iar_remote_led.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TIVA_LAUNCHPAD; PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: c:\Program Files\ARM\CSL\TexasInstruments\TivaWare; ..\pattern
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group BSP
    ../pattern/: bsp_tm4c123g_launchpad.c
  group CMSIS
    C:/Program Files/ARM/CMSIS/TexasInstruments/Tiva/startup/: startup_LM4F.s
    C:/Program Files/ARM/CMSIS/TexasInstruments/Tiva/: system_LM4F_19,2MHz.c
  group CSL
    C:/Program Files/ARM/CSL/TexasInstruments/TivaWare/driverlib/ewarm/Exe/: driverlib.a
